# Keil uVision project Demo_F429_DDS.uvprojx, settings and files
target Demo_F429_DDS (6240000::V6.24::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Demo_F429_DDS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;D:/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/STM32F4xx_HAL_Driver/Inc;D:/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;D:/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/CMSIS/Device/ST/STM32F4xx/Include;D:/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/CMSIS/Include;../delay;../demo_lvgl;../User;../MultiButton-master;..\lwrb\include\lwrb;..\event_framework;..\app;..\pid;..\bsp_sdio;..\FatFs\inc;..\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c dma.c dma2d.c fmc.c i2c.c ltdc.c sdio.c
  group Drivers/STM32F4xx_HAL_Driver
    D:/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MultiButton
    ../MultiButton-master/: bsp_multibutton.c multi_button.c
  group lvgl_demo
    ../demo_lvgl/: cooling_ui.c
  group dwt_delay
    ../delay/: delay_us.c
  group ltd_drv
    ../User/: bsp_sdram.c bsp_touch.c
  group font_lib
    ../fonts lib/: my_font_chinese_16.c my_font_chinese_18.c my_font_chinese_20.c my_font_chinese_22.c my_font_chinese_24.c my_font_chinese_32.c
  group event_framework
    ../event_framework/: event_framework.c
  group lwrb
    ../lwrb/lwrb/: lwrb.c lwrb_ex.c
  group app
    ../app/: app_control.c
  group pid
    ../pid/: PID.c
  group bsp_sdio
    ../bsp_sdio/: sd_test.c
  group usart
    ../usart/: bsp_debug_usart.c
  group fatfs
    ../FatFs/src/: diskio.c fatfs_test.c ff.c ffunicode.c
software components: CMSIS:CORE 6.1.1, LVGL:lvgl:Demo:Widgets 8.3.10, LVGL:lvgl:Essential 8.3.10, LVGL:lvgl:Extra Themes 8.3.10, LVGL:lvgl:GPU STM32-DMA2D 8.3.10, LVGL:lvgl:Libs FileSystem 8.3.10, LVGL:lvgl:Libs PNG 8.3.10, LVGL:lvgl:Libs sJPG 8.3.10, LVGL:lvgl:Porting 8.3.10
